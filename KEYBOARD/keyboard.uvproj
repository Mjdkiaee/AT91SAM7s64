# Keil uVision project keyboard.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AT91SAM7S64 Atmel
  cpu: IRAM(0x200000-0x203FFF) IROM(0x100000-0x10FFFF) CLOCK(20000000) CPUTYPE(ARM7TDMI)
  output: keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x100000 size 0x10000
  memory RVCT9: RAM 0x200000 size 0x4000
  group Source Group 1
    ./: SAM7.s asyncron putchar and getchar.c KEYBOARD.C
